<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>infoLength</value></param>
<param><key>value</key><value>22</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packetCounterLength</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Desktop/test.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Desktop/test2.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_1</value></param>
<param><key>file</key><value>/Users/marcusbunn/Desktop/test3.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Desktop/sender.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>comment</key><value>Finish the flowgraph after reading 110k bytes from the file, orn other words
500 times.</value></param>
<param><key>num_items</key><value>110000</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>packetCounterLength, infoLength</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>comment</key><value>Slow things down :)</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>comment</key><value>Slow things down :)</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>numpy.arange(65, 91,1)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>split_pack_block</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block Remover - separetes the data by only passing the counter length samples to output 1, otherwise pass zeros. 
    	Output 1 - Packet Counter
    	Output 2 - Data """

    def __init__(self, counter_length=1.0, payload_length=1.0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Split Packet Counter',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[np.int8,np.int8]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.counter_length = counter_length
        self.payload_length = payload_length
        self.aux_position = 0

    def work(self, input_items, output_items): 
    	"""example: multiply with constant"""       
    	# if self.counter_length &gt; 0: # packet counter has to be greater then one
     #    	output_items[0][:self.counter_length] = input_items[0][ :self.counter_length]
     #    	output_items[0][self.counter_length:self.payload_length] = 89 # prints Y
        	
     #    	output_items[1][ :self.counter_length] = 88 # sync blocks needs same quantity of itens on the output. Prints 'X'
     #    	output_items[1][self.counter_length:self.payload_length] = input_items[0][self.counter_length:self.payload_length]
     #    else:
     #    	output_items[0][:] = 0
     #    	output_items[1][:] = 0

        	#i*payload_length
        #when loop counter resets work funtion is called again
    	input_len = len(input_items[0]);
    	sample = input_len/(self.payload_length+self.counter_length)
    	data_length = (self.payload_length+self.counter_length)
    	data_period = 0
        for i in range(0,len(input_items[0])):
        	if i == 0 and self.aux_position  &gt; 0 : # counter has been reset
    			data_period = self.aux_position  #new 0 index = rest of samples before shift
    			print(data_period)
    		else:
    			data_period = self.aux_position+data_length 
        	if (i+1) % data_period == 0:
        		output_items[0][i] = input_items[0][i]
        		output_items[1][i] = 43 # prints + on the data stream
        		# print(i+1)
        		# print(input_items[0][i])
        		self.aux_position = (input_len-(i+1)) # stores last correct data before counter reset
        	else:
        		output_items[0][i] = 43 # prints + on the counter stream
        		output_items[1][i] = input_items[0][i]
    		# print(i)
    		# print(self.aux_position)
        return len(output_items[0])
</value></param>
<param><key>counter_length</key><value>packetCounterLength</value></param>
<param><key>payload_length</key><value>infoLength</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_file_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>split_pack_block</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>split_pack_block</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>split_pack_block</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>split_pack_block</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
