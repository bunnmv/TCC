<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_probe_mod</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>M_PSK</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,4,1,1</value></param>
<param><key>label0</key><value>DBPSK</value></param>
<param><key>label1</key><value>DQPSK</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>mod</value></param>
<param><key>type</key><value>8psk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>mod2</value></param>
<param><key>const_points</key><value>[-1-1j, -1+1j, 1+1j, 1-1j]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0, 1, 3, 2]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>psk</value></param>
<param><key>value</key><value>digital.psk_constellation(2,digital.mod_codes.NO_CODE, True)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>psk2</value></param>
<param><key>value</key><value>digital.psk_constellation(4,digital.mod_codes.NO_CODE, True)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>block_id</key><value>blks2_selector_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>function_args</key><value>1</value></param>
<param><key>function_name</key><value>set_output_index</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_0</value></param>
<param><key>block_id</key><value>psk</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>function_args</key><value>psk2</value></param>
<param><key>function_name</key><value>set_value</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>output_index</key><value>M_PSK</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Documents/engtelecom/TCC/programming/SDR/2600-0.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>comment</key><value>Finish the flowgraph after reading 110k bytes from the file, orn other words
500 times.</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>110000</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>comment</key><value>The modulator block requires packed bits as the input stream 
(that is, all 8 bits of the stream contain information).</value></param>
<param><key>constellation</key><value>psk</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0_0</value></param>
<param><key>comment</key><value>The modulator block requires packed bits as the input stream 
(that is, all 8 bits of the stream contain information).</value></param>
<param><key>constellation</key><value>psk2</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>digital_constellation_modulator_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
