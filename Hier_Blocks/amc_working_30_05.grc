<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block_amc</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>CD</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>packet_length*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>CE</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>packet_length*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable_dummy_decoder_def</key>
<param><key>id</key><value>DD</value></param>
<param><key>framebits</key><value>packet_length*8</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_dummy_encoder_def</key>
<param><key>id</key><value>DE</value></param>
<param><key>framebits</key><value>packet_length*8</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>access_code</value></param>
<param><key>value</key><value>'0101110111101101' </value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>channel_noise</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>channel_rotation</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>2*np.pi</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constellation_8psk</value></param>
<param><key>const_points</key><value>[1, 1j, -1, -1j]</value></param>
<param><key>type</key><value>8psk</value></param>
<param><key>soft_dec_lut</key><value>'Auto'</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constellation_bpsk</value></param>
<param><key>const_points</key><value>[1, 1j, -1, -1j]</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>soft_dec_lut</key><value>'Auto'</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constellation_qpsk</value></param>
<param><key>const_points</key><value>[1, 1j, -1, -1j]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>soft_dec_lut</key><value>'Auto'</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>control</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>tab@1:0,2,1,1</value></param>
<param><key>label0</key><value>Manual</value></param>
<param><key>label1</key><value>Automatic</value></param>
<param><key>label</key><value>Control</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>controller</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1:0,1,1,1</value></param>
<param><key>label0</key><value>DBPSK</value></param>
<param><key>label1</key><value>DQPSK</value></param>
<param><key>label2</key><value>D8PSK</value></param>
<param><key>label</key><value>Manual Control</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_length</value></param>
<param><key>value</key><value>(info_length+packet_counter)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>fec_choice</value></param>
<param><key>value</key><value>fec_options[mod_choice]</value></param>
<param><key>gui_hint</key><value>0,5,1,1</value></param>
<param><key>label0</key><value>Rate 1/2 C.C</value></param>
<param><key>label1</key><value>Uncoded</value></param>
<param><key>label</key><value>FEC</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fec_len_menu</value></param>
<param><key>comment</key><value>0 = Conv
1= dummy</value></param>
<param><key>value</key><value>[full_frame_bits_conv,full_frame_bits_dummy]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fec_options</value></param>
<param><key>comment</key><value>mod_choice = 0 Fec_choice =0
mod_choice = 1 Fec_choice =0
mod_choice = 2 Fec_choice =1</value></param>
<param><key>value</key><value>[0,0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_bits</value></param>
<param><key>value</key><value>packet_length*8 + packet_length*8*fec_choice</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>full_frame_bits_conv</value></param>
<param><key>value</key><value>packet_length*2*8 + len(access_code)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>full_frame_bits_dummy</value></param>
<param><key>value</key><value>packet_length*8 + len(access_code)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>info_length</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>is_conv</value></param>
<param><key>value</key><value>fec_choice == 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_name</value></param>
<param><key>value</key><value>"len_key"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_name_rx</value></param>
<param><key>value</key><value>"len_key2"</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>mod_choice</value></param>
<param><key>value</key><value>port*control + controller</value></param>
<param><key>gui_hint</key><value>0,4,1,1</value></param>
<param><key>label0</key><value>DBPSK</value></param>
<param><key>label1</key><value>DQPSK</value></param>
<param><key>label2</key><value>D8PSK</value></param>
<param><key>label</key><value>Modulation</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_counter</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_length</value></param>
<param><key>value</key><value>(info_length+packet_counter+4)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>port</value></param>
<param><key>block_id</key><value>probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>reset_call</value></param>
<param><key>comment</key><value>IF True two probes reads same value

CRC is descarting packets.

Restarts FEC and MOD</value></param>
<param><key>value</key><value>(reset_check_faster==reset_check)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>reset_check</value></param>
<param><key>block_id</key><value>probe2</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>reset_check_faster</value></param>
<param><key>block_id</key><value>probe3</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.11</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, excess_bw, 45*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4*288e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sdr_rate</value></param>
<param><key>value</key><value>8*288e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>int(sps_float)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_float</value></param>
<param><key>value</key><value>samp_rate / symbol_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>384000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>theta</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>np.pi/4</value></param>
<param><key>stop</key><value>2*np.pi</value></param>
</block>
<block>
<key>RWN_selector_3_1_cc</key>
<param><key>id</key><value>RWN_selector_3_1_cc_0</value></param>
<param><key>consume_nonselected</key><value>True</value></param>
<param><key>selected</key><value>mod_choice</value></param>
</block>
<block>
<key>RWN_selector_3_1_cc</key>
<param><key>id</key><value>RWN_selector_3_1_cc_1</value></param>
<param><key>consume_nonselected</key><value>True</value></param>
<param><key>selected</key><value>mod_choice</value></param>
</block>
<block>
<key>RWN_selector_3_1_ff</key>
<param><key>id</key><value>RWN_selector_3_1_ff_0</value></param>
<param><key>consume_nonselected</key><value>True</value></param>
<param><key>selected</key><value>mod_choice</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>amc_controller</value></param>
<param><key>average_length</key><value>100</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import datetime


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block  - This block takes the packet numbers of the received window size packets and calculates the quantity of the lost packets
       As for today, it only works for window sizes multiples of the length of the data.
    """

    def __init__(self, threshold=0.35,window_size=1, modulus=1,average_length=10, reset_call = False, state_tries = 10):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='ACM Controller',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[np.float32,np.int8]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.window_size = window_size
        self.threshold = threshold # PER threshold that controls the ACM state machine.
        self.average_length = average_length # How many measurements are used to calculate the per.
        self.modulus = modulus # modulus of the packet counter, how log it takes to return to zero.
        self.history = np.zeros(self.average_length) #vector that stores the last average length pers
        self.reset_call = reset_call # resets to BPSK e FEC
        self.state = 0 # 0 = BPSK 1 = QPSK 2 = 8PSK
        self.state_tries = state_tries # how many work calls one state is kept before changing it.
        self.work_calls = 0 # How many times the work call hass been called
        self.reset_control = False #controls reset so it does not happen very often.

        self.set_history(window_size)
    

    def calc_instant_per(self,observed):

    	 errors = sum((np.diff(observed) % self.modulus)-1)

    	 return max((float(errors)/(self.window_size+errors)),0)

    def calc_average_per(self,new_per):
        
        #make a param for treshold and to controll permanency on states.
        self.history = np.roll(self.history,1)
        
        self.history[0] = new_per

        average_per = np.mean(self.history)

        # Desired per is less than self.threshold
        if self.state == 0: #BPSK
            if self.work_calls == self.state_tries:
                self.reset_control = True
                self.work_calls = 0
                if average_per &lt;=self.threshold:
                    self.state = 1
                 
        elif self.state == 1: #QPSK
            if self.work_calls == self.state_tries:
                self.reset_control = True 
                self.work_calls = 0
                if average_per &lt;= self.threshold:
                    self.state = 2
                else:
                    self.state = 0
        else: #8PSK
            if self.work_calls == self.state_tries:
                self.reset_control = True 
                self.work_calls = 0   
                if average_per &gt; self.threshold:
                    self.state = 1
                   
        # print("History {} , Average {}".format(self.history,average_per))
        return average_per


    def work(self, input_items, output_items):
    	# Restarts machine
        if self.reset_call and self.reset_control and self.state&gt;0:
            self.reset_control = False
            self.state = 0
            self.work_calls = 0
            output_items[1][:] = 0 # Must restart port because changing just the state would not work.
            st = datetime.datetime.now().strftime("%A, %d. %B %Y %I:%M:%S%p")
            print("RESET at",st)
            return len(output_items[1]) # Must return one so produce is calles. As this is a Sync Block.

        consumed = (len(input_items[0])-self.window_size+1)
        if  consumed &lt; self.window_size:
            return 0

        self.work_calls += 1

        for i in range(0 , consumed):
            observed = input_items[0][i:self.window_size+i] %256
            #errors = sum((np.diff(observed) % self.modulus)-1)
            #per = max((float(errors)/(self.window_size+errors)),0)
            per = self.calc_instant_per(observed)
            output_items[0][i] = self.calc_average_per(per)
            output_items[1][i] = self.state
        return len(output_items[0])
</value></param>
<param><key>modulus</key><value>256</value></param>
<param><key>reset_call</key><value>reset_call</value></param>
<param><key>state_tries</key><value>10</value></param>
<param><key>threshold</key><value>0.1</value></param>
<param><key>window_size</key><value>20</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>1e-4</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1</value></param>
<param><key>const</key><value>port</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>10</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Desktop/payload.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Desktop/header_counter.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Documents/engtelecom/TCC/programming/SDR/2600-0.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>500000</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>comment</key><value>Keeps Packet Counter</value></param>
<param><key>m</key><value>packet_counter</value></param>
<param><key>n</key><value>data_length</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0</value></param>
<param><key>comment</key><value>Keeps Payload</value></param>
<param><key>m</key><value>info_length</value></param>
<param><key>n</key><value>data_length</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>packet_counter</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_1_0</value></param>
<param><key>m</key><value>fec_len_menu[fec_choice]</value></param>
<param><key>n</key><value>sum(fec_len_menu)</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>fec_len_menu[0]*fec_choice</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>packet_counter, info_length</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>lengthtagname</key><value>len_tag_name</value></param>
<param><key>ninputs</key><value>2</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>np.arange(0,256)</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>block_tags</key><value>True</value></param>
<param><key>epsilon</key><value>1.001</value></param>
<param><key>freq_offset</key><value>1e-4</value></param>
<param><key>noise_voltage</key><value>channel_noise</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1*np.exp(1j*channel_rotation)</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>fec_selector</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class selector_3_1_bb(gr.basic_block):
    def __init__(self, selected_port=0, data_length = 501):
        gr.basic_block.__init__(
            self,
            name='Simple Selector',
            in_sig=[np.uint8, np.uint8],
            out_sig=[np.uint8]
        )
        self.selected_port = selected_port
        self.data_length = data_length

    def forecast(self, noutput_items, ninput_items_required):
        for i in range(len(ninput_items_required)):
            if i == self.selected_port:
                ninput_items_required[i] = self.data_length
            else:
                ninput_items_required[i] = 0

    def general_work(self, input_items, output_items):
        L = min(len(input_items[self.selected_port]), len(output_items[0]))

        output_items[0][:L] = input_items[self.selected_port][:L]

        self.consume(self.selected_port,L)

        self.produce(0,L)
        return -2 #gr.WORK_CALLED_PRODUCE
</value></param>
<param><key>data_length</key><value>data_length</value></param>
<param><key>selected_port</key><value>fec_choice</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>symbol_rate</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>my_rx_inner</key>
<param><key>id</key><value>my_rx_inner_0</value></param>
<param><key>constellation</key><value>constellation_bpsk</value></param>
<param><key>phase_rot_after_costas_loop</key><value>theta</value></param>
<param><key>rolloff</key><value>excess_bw</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>my_rx_inner</key>
<param><key>id</key><value>my_rx_inner_0_0</value></param>
<param><key>constellation</key><value>constellation_qpsk</value></param>
<param><key>phase_rot_after_costas_loop</key><value>theta</value></param>
<param><key>rolloff</key><value>excess_bw</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>my_rx_inner</key>
<param><key>id</key><value>my_rx_inner_0_1</value></param>
<param><key>constellation</key><value>constellation_8psk</value></param>
<param><key>phase_rot_after_costas_loop</key><value>theta</value></param>
<param><key>rolloff</key><value>excess_bw</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>my_tx_inner</key>
<param><key>id</key><value>my_tx_inner_0</value></param>
<param><key>constellation</key><value>constellation_bpsk</value></param>
<param><key>rolloff</key><value>excess_bw</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>my_tx_inner</key>
<param><key>id</key><value>my_tx_inner_0_0</value></param>
<param><key>constellation</key><value>constellation_qpsk</value></param>
<param><key>rolloff</key><value>excess_bw</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>my_tx_inner</key>
<param><key>id</key><value>my_tx_inner_0_1</value></param>
<param><key>constellation</key><value>constellation_8psk</value></param>
<param><key>rolloff</key><value>excess_bw</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>per_calc_port_select</value></param>
<param><key>average_length</key><value>5</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block  - This block takes the packet numbers of the received window size packets and calculates the quantity of the lost packets
       As for today, it only works for window sizes multiples of the length of the data.
    """

    def __init__(self, window_size=1, modulus=1,average_length=10):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='PER Calculator',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[np.float32,np.int8]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.window_size = window_size
        self.average_length = average_length
        self.modulus = modulus
        self.history = np.zeros(self.average_length)
        self.set_history(window_size)

    def calc_average_per(self,new_per):
        
        self.history = np.roll(self.history,1)
        
        self.history[0] = new_per

        average_per = np.mean(self.history)

    	if  0 &lt;= average_per &lt;= 0.35:

            selected_port = 2

        elif 0.35 &lt; average_per &lt;= 0.55:

            selected_port = 1

        else:

            selected_port = 0

        # print("History {} , Average {}".format(self.history,average_per))
        return average_per,selected_port


    def work(self, input_items, output_items):

        consumed = (len(input_items[0])-self.window_size+1)
        if  consumed &lt; self.window_size:
            return 0    
        for i in range(0 , consumed):
            # if self.window_size+i &lt; len(input_items[0]):
            observed = input_items[0][i:self.window_size+i] %256

            errors = sum((np.diff(observed) % self.modulus)-1)

            per = max((float(errors)/(self.window_size+errors)),0)
            # print("Observed {}".format(observed))
            # print("PER {}".format(per))
            output_items[0][i],output_items[1][i] = self.calc_average_per(per)

        return len(output_items[0])
</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>modulus</key><value>256</value></param>
<param><key>window_size</key><value>20</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe</value></param>
<param><key>comment</key><value>MOD e FEC</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe2</value></param>
<param><key>comment</key><value>Restart</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe3</value></param>
<param><key>comment</key><value>Restart Check</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>6,1,1,2</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"PER"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_1</value></param>
<param><key>gui_hint</key><value>6,3,1,5</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Port"</value></param>
<param><key>update_time</key><value>0.04</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ncols</key><value>1</value></param>
<param><key>nrows</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>100</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>stemplot</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>1,1,5,5</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>After Decoding</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>name</key><value>"After CRC"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_tag</key><value>"len_key2"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(samp_rate)</value></param>
<param><key>interp</key><value>int(sdr_rate)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>int(sdr_rate)</value></param>
<param><key>interp</key><value>int(samp_rate)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rx_outer</key>
<param><key>id</key><value>rx_outer_1</value></param>
<param><key>decoder</key><value>CD</value></param>
<param><key>packet_length</key><value>packet_length</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>len_tag_name_rx</key><value>len_tag_name</value></param>
</block>
<block>
<key>rx_outer</key>
<param><key>id</key><value>rx_outer_2</value></param>
<param><key>decoder</key><value>DD</value></param>
<param><key>packet_length</key><value>packet_length</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>len_tag_name_rx</key><value>len_tag_name_rx</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>After Costas</value></param>
<param><key>label1</key><value>PER Rate</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>tx_outer</key>
<param><key>id</key><value>tx_outer_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>data_length</key><value>data_length</value></param>
<param><key>encoder</key><value>CE</value></param>
<param><key>len_tag_name</key><value>len_tag_name</value></param>
</block>
<block>
<key>tx_outer</key>
<param><key>id</key><value>tx_outer_0_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>data_length</key><value>data_length</value></param>
<param><key>encoder</key><value>DE</value></param>
<param><key>len_tag_name</key><value>len_tag_name</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>tx_outer</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>tx_inner</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>channel</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>demoduled</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>tx_outer</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>tx_inner</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>channel</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>demoduled</value></param>
</block>
<connection><source_block_id>RWN_selector_3_1_cc_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_3_1_cc_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_3_1_ff_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>amc_controller</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>amc_controller</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>amc_controller</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>amc_controller</source_block_id><sink_block_id>probe</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_1</source_block_id><sink_block_id>qtgui_number_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>probe3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>amc_controller</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>probe2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_1_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>tx_outer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>tx_outer_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0</source_block_id><sink_block_id>my_tx_inner_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0</source_block_id><sink_block_id>my_tx_inner_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0</source_block_id><sink_block_id>my_tx_inner_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>blocks_keep_m_in_n_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_selector</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_selector</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_rx_inner_0</source_block_id><sink_block_id>RWN_selector_3_1_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_rx_inner_0</source_block_id><sink_block_id>RWN_selector_3_1_cc_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_rx_inner_0_0</source_block_id><sink_block_id>RWN_selector_3_1_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>my_rx_inner_0_0</source_block_id><sink_block_id>RWN_selector_3_1_cc_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>my_rx_inner_0_1</source_block_id><sink_block_id>RWN_selector_3_1_ff_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>my_rx_inner_0_1</source_block_id><sink_block_id>RWN_selector_3_1_cc_1</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>my_tx_inner_0</source_block_id><sink_block_id>RWN_selector_3_1_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_tx_inner_0_0</source_block_id><sink_block_id>RWN_selector_3_1_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>my_tx_inner_0_1</source_block_id><sink_block_id>RWN_selector_3_1_cc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_outer_1</source_block_id><sink_block_id>fec_selector</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_outer_2</source_block_id><sink_block_id>fec_selector</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>tx_outer_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_outer_0_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_tag_gate_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>my_rx_inner_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>my_rx_inner_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>my_rx_inner_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>rx_outer_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>rx_outer_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
