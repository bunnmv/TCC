<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tx_outer</value></param>
<param><key>category</key><value>[AMC Hier Blocks]</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>crc_length</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_encoded_length</value></param>
<param><key>comment</key><value>Somehow, on the encoder fec.rate() returns 1/the_actual_rate. 
So a 1/2 returns  2</value></param>
<param><key>value</key><value>int((packet_counter+info_length+crc_length) *encoder.rate())</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>access_code</value></param>
<param><key>label</key><value>Access Code</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'0101110111101101' </value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_tx_convolutional</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>comment</key><value>FEC needs unpacked

MSB -&gt; For FEC</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>len_tag_name</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>packet_counter, info_length</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_tx_convolutional</value></param>
<param><key>len_tag_key</key><value>len_tag_name</value></param>
<param><key>packet_len</key><value>packet_counter+info_length</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>np.arange(0,256)</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_tx_convolutional</value></param>
<param><key>lengthtagname</key><value>len_tag_name</value></param>
<param><key>check</key><value>False</value></param>
<param><key>packed</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>encoder</value></param>
<param><key>label</key><value>Encoder Object</value></param>
<param><key>value</key><value>fec.cc_encoder_make(4000, 7, 2, ([79,109]), 0, fec.CC_STREAMING, False)</value></param>
</block>
<block>
<key>fec_extended_tagged_encoder</key>
<param><key>id</key><value>fec_extended_tagged_encoder_tx_convolutional</value></param>
<param><key>comment</key><value>110110 puncture for 3/4 rate

Inner vai ate aqui + o header formatter</value></param>
<param><key>encoder_list</key><value>encoder</value></param>
<param><key>lentagname</key><value>len_tag_name</value></param>
<param><key>mtu</key><value>packet_counter+info_length+crc_length</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_bits</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Frame Bits</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>info</value></param>
<param><key>label</key><value>info</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>info_length</value></param>
<param><key>label</key><value>Info Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_tag_name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'len_key'</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>my_framer</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt


class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    """
    ATTENTION!

    This blocks works with unpacked bits in the input and in the output.
    """
    def __init__(self, access_code=None, payload_length=100, tag_name = "length"):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='My Frammer',   # will show up in GRC
            in_sig=[np.uint8],
            out_sig=[np.uint8]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.access_code = access_code
        self.payload_length = payload_length
        self.tag_name = tag_name
        # enum      tag_propagation_policy_t { TPP_DONT = 0, TPP_ALL_TO_ALL = 1, TPP_ONE_TO_ONE = 2 }
        self.set_tag_propagation_policy(0)


    def general_work(self, input_items, output_items):

        if len(input_items[0]) &lt; 8*self.payload_length:
            return 0

        access_code_binary = np.array([int(b) for b in self.access_code], dtype=np.uint8)

        payload = input_items[0][: 8*self.payload_length]
        packet = np.concatenate([access_code_binary, payload])

        if len(output_items[0]) &lt; len(packet):
            return 0

        self.add_item_tag(0, # Port number
                 self.nitems_written(0), # Offset
                 pmt.intern(self.tag_name), # Key
                 pmt.to_pmt(len(packet)) # Value
        )
        output_items[0][: len(packet)] = packet

        self.consume(0, 8*self.payload_length)

        return len(packet)
</value></param>
<param><key>payload_length</key><value>data_encoded_length</value></param>
<param><key>tag_name</key><value>len_tag_name</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>packet_counter</value></param>
<param><key>label</key><value>Packet Counter Bytes</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>toMod</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>toMod</value></param>
</block>
<connection><source_block_id>blocks_repack_bits_bb_tx_convolutional</source_block_id><sink_block_id>fec_extended_tagged_encoder_tx_convolutional</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_tx_convolutional</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_tx_convolutional</source_block_id><sink_block_id>digital_crc32_bb_tx_convolutional</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_tx_convolutional</source_block_id><sink_block_id>blocks_repack_bits_bb_tx_convolutional</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_encoder_tx_convolutional</source_block_id><sink_block_id>my_framer</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>info</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>my_framer</source_block_id><sink_block_id>toMod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
