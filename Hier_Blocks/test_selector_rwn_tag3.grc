<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>CD</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>packetLength*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>FEC</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label0</key><value>Dummy</value></param>
<param><key>label1</key><value>Rate 1/2 C.C</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>access_code</value></param>
<param><key>value</key><value>'0101110111101101' * 3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dataLength</value></param>
<param><key>value</key><value>(infoLength+packetCounterLength)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_bits</value></param>
<param><key>value</key><value>packetLength*8 + packetLength*8*FEC</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>infoLength</value></param>
<param><key>value</key><value>22*10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_name</value></param>
<param><key>value</key><value>"len_key"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_name_2</value></param>
<param><key>value</key><value>"len_key2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_name_rx</value></param>
<param><key>value</key><value>"len_key2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packetCounterLength</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packetLength</value></param>
<param><key>value</key><value>(infoLength+packetCounterLength+4)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, excess_bw, 45*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>RWN_selector_1_3_bb</key>
<param><key>id</key><value>RWN_selector_1_3_bb_1</value></param>
<param><key>produce_on_nonselected</key><value>False</value></param>
<param><key>selected</key><value>FEC</value></param>
</block>
<block>
<key>RWN_selector_1_3_bb</key>
<param><key>id</key><value>RWN_selector_1_3_bb_1_0</value></param>
<param><key>comment</key><value>Elimina Tags

Produce = FALSE</value></param>
<param><key>produce_on_nonselected</key><value>False</value></param>
<param><key>selected</key><value>0</value></param>
</block>
<block>
<key>RWN_selector_1_3_cc</key>
<param><key>id</key><value>RWN_selector_1_3_cc_0</value></param>
<param><key>produce_on_nonselected</key><value>False</value></param>
<param><key>selected</key><value>0</value></param>
</block>
<block>
<key>RWN_selector_1_3_ff</key>
<param><key>id</key><value>RWN_selector_1_3_ff_0</value></param>
<param><key>produce_on_nonselected</key><value>False</value></param>
<param><key>selected</key><value>FEC</value></param>
</block>
<block>
<key>RWN_selector_3_1_bb</key>
<param><key>id</key><value>RWN_selector_3_1_bb_0</value></param>
<param><key>comment</key><value>Propaga Tags Errado

Consume = TRUE</value></param>
<param><key>consume_nonselected</key><value>True</value></param>
<param><key>selected</key><value>FEC</value></param>
</block>
<block>
<key>RWN_selector_3_1_bb</key>
<param><key>id</key><value>RWN_selector_3_1_bb_1</value></param>
<param><key>consume_nonselected</key><value>True</value></param>
<param><key>selected</key><value>FEC</value></param>
</block>
<block>
<key>RWN_selector_3_1_bb</key>
<param><key>id</key><value>RWN_selector_3_1_bb_1_0</value></param>
<param><key>consume_nonselected</key><value>True</value></param>
<param><key>selected</key><value>FEC</value></param>
</block>
<block>
<key>RWN_selector_3_1_ff</key>
<param><key>id</key><value>RWN_selector_3_1_ff_0</value></param>
<param><key>consume_nonselected</key><value>True</value></param>
<param><key>selected</key><value>0</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Desktop/payload.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Documents/engtelecom/TCC/programming/SDR/2600-0.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>110000</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>comment</key><value>Keeps Payload</value></param>
<param><key>m</key><value>infoLength</value></param>
<param><key>n</key><value>dataLength</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>packetCounterLength</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_1_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_convolutional</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>comment</key><value>Tagged Stream to PDU block up ahead needs packed bytes

MSB -&gt; Because of FEC</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>len_tag_name_rx</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>len_tag_name</value></param>
<param><key>packet_len</key><value>frame_bits</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>filter</key><value>"len_key2"</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>comment</key><value>Slow things down :)</value></param>
<param><key>samples_per_second</key><value>samp_rate*1000</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>block_tags</key><value>True</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>noise_voltage</key><value>0.2</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_convolutional</value></param>
<param><key>lengthtagname</key><value>len_tag_name_rx</value></param>
<param><key>check</key><value>True</value></param>
<param><key>packed</key><value>True</value></param>
</block>
<block>
<key>fec_extended_tagged_decoder</key>
<param><key>id</key><value>fec_extended_tagged_decoder_convolutional</value></param>
<param><key>comment</key><value>110110 puncture for 3/4 rate</value></param>
<param><key>decoder_list</key><value>CD</value></param>
<param><key>lentagname</key><value>len_tag_name_rx</value></param>
<param><key>mtu</key><value>packetLength</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>my_correlator_convolutional</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt


class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    def __init__(self, access_code=None, payload_length=100, threshold=0,tag_name="len_key2"):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='My Correlator Block',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.access_code = access_code
        self.payload_length = payload_length
        self.threshold = threshold
        self.tag_name = tag_name

        self.mode = 'find'

        self.set_min_output_buffer(2**16)

        self.set_tag_propagation_policy(0)


    def general_work(self, input_items, output_items):
        if self.mode == 'output':
            return self.general_work_output(input_items, output_items)
        elif self.mode == 'find':
            return self.general_work_find(input_items, output_items)

    def general_work_output(self, input_items, output_items):
        L_in = len(input_items[0])
        # print(L_in) #input is never 10K for the CC 1/2 rate case.
        L_out = len(output_items[0])
        L_payload = self.payload_length # in bits

        if L_in &lt; L_payload or L_out &lt; L_payload:
            # print(L_in) #input is never 10K for the CC 1/2 rate case.
            # print(L_out)
            # print(L_payload)
            return 0


        self.add_item_tag(0, # Port number
            self.nitems_written(0), # Offset
            pmt.intern(self.tag_name), # Key
            pmt.to_pmt(L_payload) # Value
        )
        output_items[0][:L_payload] = input_items[0][:L_payload]
        self.consume(0, L_payload)

        # ~print('Outputted {} items.'.format(L_payload))

        self.mode = 'find'

        return L_payload

    def general_work_find(self, input_items, output_items):
        L_in = len(input_items[0])

        if L_in &lt; len(self.access_code) :
            return 0

        access_code_binary = np.array([int(b) for b in self.access_code], dtype=np.int)
        input_decoded = np.array(input_items[0] &gt; 0, dtype=np.int)

        corr = np.correlate(2*input_decoded-1, 2*access_code_binary-1)
        matches = np.flatnonzero(corr &gt;= len(self.access_code) - self.threshold)
        if len(matches) == 0:
            self.consume(0, L_in - len(self.access_code))
        else:
            self.consume(0, matches[0] + len(self.access_code))
            self.mode = 'output'

        return 0
</value></param>
<param><key>payload_length</key><value>frame_bits</value></param>
<param><key>tag_name</key><value>len_tag_name_rx</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"FEC Decoded"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>tr_tag</key><value>"len_key2"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rx_inner_bpsk</key>
<param><key>id</key><value>rx_inner_bpsk_0</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>nfilts</key><value>nfilts</value></param>
<param><key>rrc_taps</key><value>rrc_taps</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>theta</key><value>0</value></param>
</block>
<block>
<key>rx_outer_convolutional</key>
<param><key>id</key><value>rx_outer_convolutional_0</value></param>
<param><key>comment</key><value>My correlator problem with 2*packetLength*8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frame_bits</key><value>frame_bits</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>len_tag_name_rx</key><value>len_tag_name_rx</value></param>
<param><key>packetCounterLength</key><value>packetCounterLength</value></param>
<param><key>packetLength</key><value>packetLength</value></param>
</block>
<block>
<key>rx_outer_dummy</key>
<param><key>id</key><value>rx_outer_dummy_0</value></param>
<param><key>frame_bits</key><value>frame_bits</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>len_tag_name_rx</key><value>len_tag_name_rx</value></param>
<param><key>packetCounterLength</key><value>packetCounterLength</value></param>
<param><key>packetLength</key><value>packetLength</value></param>
</block>
<block>
<key>tx_inner_bpsk</key>
<param><key>id</key><value>tx_inner_bpsk_0_0</value></param>
<param><key>frame_bits</key><value>frame_bits</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>len_tag_name</key><value>len_tag_name</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>tx_outer_CE</key>
<param><key>id</key><value>tx_outer_CE_0</value></param>
<param><key>dataLength</key><value>dataLength</value></param>
<param><key>infoLength</key><value>infoLength</value></param>
<param><key>len_tag_name</key><value>len_tag_name</value></param>
<param><key>packetCounterLength</key><value>packetCounterLength</value></param>
<param><key>packetLength</key><value>packetLength</value></param>
</block>
<block>
<key>tx_outer_dummy</key>
<param><key>id</key><value>tx_outer_dummy_0</value></param>
<param><key>dataLength</key><value>dataLength</value></param>
<param><key>infoLength</key><value>infoLength</value></param>
<param><key>len_tag_name</key><value>len_tag_name</value></param>
<param><key>packetCounterLength</key><value>packetCounterLength</value></param>
<param><key>packetLength</key><value>packetLength</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>sync</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>sync</value></param>
</block>
<connection><source_block_id>RWN_selector_1_3_bb_1</source_block_id><sink_block_id>tx_outer_dummy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_bb_1</source_block_id><sink_block_id>tx_outer_CE_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_bb_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_bb_1_0</source_block_id><sink_block_id>blocks_tag_gate_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_bb_1_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_bb_1_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_cc_0</source_block_id><sink_block_id>rx_inner_bpsk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_cc_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_cc_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_ff_0</source_block_id><sink_block_id>rx_outer_dummy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_ff_0</source_block_id><sink_block_id>my_correlator_convolutional</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_ff_0</source_block_id><sink_block_id>rx_outer_convolutional_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_ff_0</source_block_id><sink_block_id>blocks_null_sink_2</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_3_1_bb_0</source_block_id><sink_block_id>RWN_selector_1_3_bb_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_3_1_bb_1</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_3_1_bb_1_0</source_block_id><sink_block_id>blocks_char_to_float_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_3_1_ff_0</source_block_id><sink_block_id>RWN_selector_1_3_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_null_source_1</source_block_id><sink_block_id>RWN_selector_3_1_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_null_source_1</source_block_id><sink_block_id>RWN_selector_3_1_ff_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_null_source_1_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_null_source_1_1</source_block_id><sink_block_id>RWN_selector_3_1_bb_1_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_convolutional</source_block_id><sink_block_id>digital_crc32_bb_convolutional</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>tx_inner_bpsk_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>RWN_selector_1_3_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>RWN_selector_1_3_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_convolutional</source_block_id><sink_block_id>RWN_selector_3_1_bb_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_convolutional</source_block_id><sink_block_id>RWN_selector_3_1_bb_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_convolutional</source_block_id><sink_block_id>blocks_repack_bits_bb_convolutional</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_correlator_convolutional</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_correlator_convolutional</source_block_id><sink_block_id>fec_extended_tagged_decoder_convolutional</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_inner_bpsk_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_inner_bpsk_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_outer_convolutional_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_1_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_outer_dummy_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_outer_dummy_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_inner_bpsk_0_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_outer_CE_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>tx_outer_dummy_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>RWN_selector_3_1_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
