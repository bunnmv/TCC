<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>FEC</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label0</key><value>Dummy</value></param>
<param><key>label1</key><value>Rate 1/2 C.C</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>access_code</value></param>
<param><key>value</key><value>'0101110111101101' * 3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dataLength</value></param>
<param><key>value</key><value>(infoLength+packetCounterLength)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw_0</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frameLength</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>packetLength+len(access_code)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frameLength</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>packetLength+12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>infoLength</value></param>
<param><key>value</key><value>22*10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_name</value></param>
<param><key>value</key><value>"len_key"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_name_rx</value></param>
<param><key>value</key><value>"len_key2"</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>mod_select</value></param>
<param><key>value</key><value>2</value></param>
<param><key>label0</key><value>D8PSK</value></param>
<param><key>label1</key><value>DQPSK</value></param>
<param><key>label2</key><value>DBPSK</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packetCounterLength</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packetLength</value></param>
<param><key>value</key><value>(infoLength+packetCounterLength+4)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, excess_bw, 45*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>RWN_selector_1_3_bb</key>
<param><key>id</key><value>RWN_selector_1_3_bb_0</value></param>
<param><key>produce_on_nonselected</key><value>False</value></param>
<param><key>selected</key><value>mod_select</value></param>
</block>
<block>
<key>RWN_selector_1_3_bb</key>
<param><key>id</key><value>RWN_selector_1_3_bb_1</value></param>
<param><key>produce_on_nonselected</key><value>False</value></param>
<param><key>selected</key><value>FEC</value></param>
</block>
<block>
<key>RWN_selector_1_3_cc</key>
<param><key>id</key><value>RWN_selector_1_3_cc_0</value></param>
<param><key>produce_on_nonselected</key><value>False</value></param>
<param><key>selected</key><value>mod_select</value></param>
</block>
<block>
<key>RWN_selector_1_3_ff</key>
<param><key>id</key><value>RWN_selector_1_3_ff_0</value></param>
<param><key>produce_on_nonselected</key><value>False</value></param>
<param><key>selected</key><value>FEC</value></param>
</block>
<block>
<key>RWN_selector_3_1_bb</key>
<param><key>id</key><value>RWN_selector_3_1_bb_0</value></param>
<param><key>consume_nonselected</key><value>True</value></param>
<param><key>selected</key><value>FEC</value></param>
</block>
<block>
<key>RWN_selector_3_1_bb</key>
<param><key>id</key><value>RWN_selector_3_1_bb_1</value></param>
<param><key>consume_nonselected</key><value>False</value></param>
<param><key>selected</key><value>FEC</value></param>
</block>
<block>
<key>RWN_selector_3_1_bb</key>
<param><key>id</key><value>RWN_selector_3_1_bb_1_0</value></param>
<param><key>consume_nonselected</key><value>False</value></param>
<param><key>selected</key><value>FEC</value></param>
</block>
<block>
<key>RWN_selector_3_1_cc</key>
<param><key>id</key><value>RWN_selector_3_1_cc_0</value></param>
<param><key>consume_nonselected</key><value>False</value></param>
<param><key>selected</key><value>mod_select</value></param>
</block>
<block>
<key>RWN_selector_3_1_cc</key>
<param><key>id</key><value>RWN_selector_3_1_cc_1</value></param>
<param><key>consume_nonselected</key><value>False</value></param>
<param><key>selected</key><value>mod_select</value></param>
</block>
<block>
<key>RWN_selector_3_1_ff</key>
<param><key>id</key><value>RWN_selector_3_1_ff_0</value></param>
<param><key>consume_nonselected</key><value>False</value></param>
<param><key>selected</key><value>mod_select</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Desktop/payload.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Documents/engtelecom/TCC/programming/SDR/2600-0.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>11000000</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>comment</key><value>Keeps Payload</value></param>
<param><key>m</key><value>infoLength</value></param>
<param><key>n</key><value>dataLength</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>packetCounterLength</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>comment</key><value>Slow things down :)</value></param>
<param><key>samples_per_second</key><value>samp_rate*1000</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>block_tags</key><value>True</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>noise_voltage</key><value>0.2</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"FEC Decoded"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>tr_tag</key><value>"len_key2"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rx_inner_8psk</key>
<param><key>id</key><value>rx_inner_8psk_0</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>nfilts</key><value>nfilts</value></param>
<param><key>rrc_taps</key><value>rrc_taps</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>theta</key><value>0</value></param>
</block>
<block>
<key>rx_inner_bpsk</key>
<param><key>id</key><value>rx_inner_bpsk_0</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>nfilts</key><value>nfilts</value></param>
<param><key>rrc_taps</key><value>rrc_taps</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>theta</key><value>0</value></param>
</block>
<block>
<key>rx_inner_qpsk</key>
<param><key>id</key><value>rx_inner_qpsk_0</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>nfilts</key><value>nfilts</value></param>
<param><key>rrc_taps</key><value>rrc_taps</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>theta</key><value>0</value></param>
</block>
<block>
<key>rx_outer_convolutional</key>
<param><key>id</key><value>rx_outer_convolutional_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>len_tag_name_rx</key><value>len_tag_name_rx</value></param>
<param><key>packetCounterLength</key><value>packetCounterLength</value></param>
<param><key>packetLength</key><value>packetLength</value></param>
</block>
<block>
<key>rx_outer_dummy</key>
<param><key>id</key><value>rx_outer_dummy_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>len_tag_name_rx</key><value>len_tag_name_rx</value></param>
<param><key>packetCounterLength</key><value>packetCounterLength</value></param>
<param><key>packetLength</key><value>packetLength</value></param>
</block>
<block>
<key>tx_inner_8psk</key>
<param><key>id</key><value>tx_inner_8psk_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>len_tag_name</key><value>len_tag_name</value></param>
<param><key>payloadLength</key><value>packetLength +(packetLength*FEC)</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>tx_inner_bpsk</key>
<param><key>id</key><value>tx_inner_bpsk_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>len_tag_name</key><value>len_tag_name</value></param>
<param><key>payloadLength</key><value>packetLength +(packetLength*FEC)</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>tx_inner_qpsk</key>
<param><key>id</key><value>tx_inner_qpsk_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>len_tag_name</key><value>len_tag_name</value></param>
<param><key>payloadLength</key><value>packetLength +(packetLength*FEC)</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>tx_outer_CE</key>
<param><key>id</key><value>tx_outer_CE_0</value></param>
<param><key>dataLength</key><value>dataLength</value></param>
<param><key>infoLength</key><value>infoLength</value></param>
<param><key>len_tag_name</key><value>len_tag_name</value></param>
<param><key>packetCounterLength</key><value>packetCounterLength</value></param>
<param><key>packetLength</key><value>packetLength</value></param>
</block>
<block>
<key>tx_outer_dummy</key>
<param><key>id</key><value>tx_outer_dummy_0</value></param>
<param><key>dataLength</key><value>dataLength</value></param>
<param><key>infoLength</key><value>infoLength</value></param>
<param><key>len_tag_name</key><value>len_tag_name</value></param>
<param><key>packetCounterLength</key><value>packetCounterLength</value></param>
<param><key>packetLength</key><value>packetLength</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>fec_select</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>fec_select</value></param>
</block>
<connection><source_block_id>RWN_selector_1_3_bb_0</source_block_id><sink_block_id>tx_inner_8psk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_bb_0</source_block_id><sink_block_id>tx_inner_qpsk_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_bb_0</source_block_id><sink_block_id>tx_inner_bpsk_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_bb_1</source_block_id><sink_block_id>tx_outer_dummy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_bb_1</source_block_id><sink_block_id>tx_outer_CE_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_bb_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_cc_0</source_block_id><sink_block_id>rx_inner_8psk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_cc_0</source_block_id><sink_block_id>rx_inner_qpsk_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_cc_0</source_block_id><sink_block_id>rx_inner_bpsk_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_ff_0</source_block_id><sink_block_id>rx_outer_dummy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_ff_0</source_block_id><sink_block_id>rx_outer_convolutional_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_1_3_ff_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_3_1_bb_0</source_block_id><sink_block_id>RWN_selector_1_3_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_3_1_bb_1</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_3_1_bb_1_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_3_1_cc_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_3_1_cc_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RWN_selector_3_1_ff_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_null_source_1</source_block_id><sink_block_id>RWN_selector_3_1_bb_1_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_null_source_1_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>RWN_selector_1_3_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>RWN_selector_1_3_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_inner_8psk_0</source_block_id><sink_block_id>RWN_selector_3_1_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_inner_8psk_0</source_block_id><sink_block_id>RWN_selector_3_1_ff_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_inner_bpsk_0</source_block_id><sink_block_id>RWN_selector_3_1_cc_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>rx_inner_bpsk_0</source_block_id><sink_block_id>RWN_selector_3_1_ff_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>rx_inner_qpsk_0</source_block_id><sink_block_id>RWN_selector_3_1_cc_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_inner_qpsk_0</source_block_id><sink_block_id>RWN_selector_3_1_ff_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_outer_convolutional_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_outer_convolutional_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_1_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rx_outer_dummy_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_outer_dummy_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_inner_8psk_0</source_block_id><sink_block_id>RWN_selector_3_1_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_inner_bpsk_0</source_block_id><sink_block_id>RWN_selector_3_1_cc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>tx_inner_qpsk_0</source_block_id><sink_block_id>RWN_selector_3_1_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>tx_outer_CE_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>tx_outer_dummy_0</source_block_id><sink_block_id>RWN_selector_3_1_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>RWN_selector_1_3_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
