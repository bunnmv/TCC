<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_outer_convolutional</value></param>
<param><key>category</key><value>[AMC Hier Blocks]</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>CD</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>frameLength*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>access_code</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'101010'</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_convolutional</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>comment</key><value>Tagged Stream to PDU block up ahead needs packed bytes

MSB -&gt; Because of FEC</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>len_tag_name_rx</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>crc_out</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>crc_out</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dataLength</value></param>
<param><key>label</key><value>dataLength</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_convolutional</value></param>
<param><key>lengthtagname</key><value>len_tag_name_rx</value></param>
<param><key>check</key><value>True</value></param>
<param><key>packed</key><value>True</value></param>
</block>
<block>
<key>fec_extended_tagged_decoder</key>
<param><key>id</key><value>fec_extended_tagged_decoder_convolutional</value></param>
<param><key>comment</key><value>110110 puncture for 3/4 rate</value></param>
<param><key>decoder_list</key><value>CD</value></param>
<param><key>lentagname</key><value>len_tag_name_rx</value></param>
<param><key>mtu</key><value>packetLength</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frameLength</value></param>
<param><key>label</key><value>frameLength</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>fromFEC_RX</value></param>
<param><key>label</key><value>fromFEC_RX</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>infoLength</value></param>
<param><key>label</key><value>infoLength</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_tag_name_rx</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'len_key2'</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>my_correlator_convolutional</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt


class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    def __init__(self, access_code=None, payload_length=100, threshold=0,tag_name="len_key2"):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='My Correlator Block',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.access_code = access_code
        self.payload_length = payload_length
        self.threshold = threshold
        self.tag_name = tag_name

        self.mode = 'find'

        self.set_min_output_buffer(2**16)

        self.set_tag_propagation_policy(0)


    def general_work(self, input_items, output_items):
        if self.mode == 'output':
            return self.general_work_output(input_items, output_items)
        elif self.mode == 'find':
            return self.general_work_find(input_items, output_items)

    def general_work_output(self, input_items, output_items):
        L_in = len(input_items[0])
        L_out = len(output_items[0])
        L_payload = self.payload_length * 8  # in bits

        if L_in &lt; L_payload or L_out &lt; L_payload:
            return 0


        self.add_item_tag(0, # Port number
            self.nitems_written(0), # Offset
            pmt.intern(self.tag_name), # Key
            pmt.to_pmt(L_payload) # Value
        )
        output_items[0][:L_payload] = input_items[0][:L_payload]
        self.consume(0, L_payload)

        # ~print('Outputted {} items.'.format(L_payload))

        self.mode = 'find'

        return L_payload

    def general_work_find(self, input_items, output_items):
        L_in = len(input_items[0])

        if L_in &lt; len(self.access_code) :
            return 0

        access_code_binary = np.array([int(b) for b in self.access_code], dtype=np.int)
        input_decoded = np.array(input_items[0] &gt; 0, dtype=np.int)

        corr = np.correlate(2*input_decoded-1, 2*access_code_binary-1)
        matches = np.flatnonzero(corr &gt;= len(self.access_code) - self.threshold)
        if len(matches) == 0:
            self.consume(0, L_in - len(self.access_code))
        else:
            self.consume(0, matches[0] + len(self.access_code))
            self.mode = 'output'

        return 0
</value></param>
<param><key>payload_length</key><value>packetLength*2</value></param>
<param><key>tag_name</key><value>len_tag_name_rx</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>packetCounterLength</value></param>
<param><key>label</key><value>packetCounterLength</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>packetLength</value></param>
<param><key>label</key><value>packetLength</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>fromFec</value></param>
</block>
<connection><source_block_id>blocks_repack_bits_bb_convolutional</source_block_id><sink_block_id>digital_crc32_bb_convolutional</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_convolutional</source_block_id><sink_block_id>crc_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_convolutional</source_block_id><sink_block_id>blocks_repack_bits_bb_convolutional</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_convolutional</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fromFEC_RX</source_block_id><sink_block_id>my_correlator_convolutional</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_correlator_convolutional</source_block_id><sink_block_id>fec_extended_tagged_decoder_convolutional</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
