<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mpsk_stage3</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>CC</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>CC_D</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>9</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Delay time</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_volt</value></param>
<param><key>value</key><value>0.0001</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Noise Voltage</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>qpsk2</value></param>
<param><key>type</key><value>8psk</value></param>
<param><key>precision</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>arity</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[1.0 + 0.0j, ]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>time_offset</value></param>
<param><key>value</key><value>1.00</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Timing Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.999</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>1.001</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>timing_loop_bw</value></param>
<param><key>value</key><value>6.28/100.0</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>Time: BW</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>0.2</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>int(np.power(2,7)-1)</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>int(np.power(2,7)-1)</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>int(np.power(2,7)-1)</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>int(np.log2(arity))</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Documents/engtelecom/SDR/bob.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>noise_voltage</key><value>noise_volt</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>taps</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>mu</key><value>0.01</value></param>
<param><key>modulus</key><value>1</value></param>
<param><key>num_taps</key><value>15</value></param>
<param><key>sps</key><value>1</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>qpsk2</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>qpsk2</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0</value></param>
<param><key>constellation</key><value>qpsk2</value></param>
</block>
<block>
<key>digital_lms_dd_equalizer_cc</key>
<param><key>id</key><value>digital_lms_dd_equalizer_cc_0</value></param>
<param><key>cnst</key><value>qpsk2</value></param>
<param><key>mu</key><value>0.01</value></param>
<param><key>num_taps</key><value>11</value></param>
<param><key>sps</key><value>1</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>timing_loop_bw</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps*1.00</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0</value></param>
<param><key>decoder_list</key><value>CC_D</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_encoder</key>
<param><key>id</key><value>fec_extended_encoder_0</value></param>
<param><key>encoder_list</key><value>CC</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>label1</key><value>RX Data</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,2,1,2</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>label1</key><value>Timing Recov.</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>1,2,1,2</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>label1</key><value>Timing Recov.</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>label1</key><value>RX Data</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Rx</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>RX</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>fec_extended_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>fec_extended_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0</source_block_id><sink_block_id>fec_extended_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_lms_dd_equalizer_cc_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_lms_dd_equalizer_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_lms_dd_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
