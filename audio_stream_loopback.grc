<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>packet_loopback_hier</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>Const_HDR</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>Const_PLD</value></param>
<param><key>const_points</key><value>digital.psk_4()[0]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_4()[1]</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>Const_PLD</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>dec</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable_dummy_decoder_def</key>
<param><key>id</key><value>dec</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_polar_decoder_sc_def</key>
<param><key>id</key><value>dec</value></param>
<param><key>num_info_bits</key><value>4</value></param>
<param><key>block_size</key><value>8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frozen_bit_positions</key><value>[0,1,2,4]</value></param>
<param><key>frozen_bit_values</key><value>[0,0,0,0]</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_repetition_decoder_def</key>
<param><key>id</key><value>dec</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>rep</key><value>rep</value></param>
<param><key>prob</key><value>0.5</value></param>
</block>
<block>
<key>variable_dummy_decoder_def</key>
<param><key>id</key><value>dec_hdr</value></param>
<param><key>framebits</key><value>hdr_format.header_nbits()</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_repetition_decoder_def</key>
<param><key>id</key><value>dec_hdr</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>framebits</key><value>hdr_format.header_nbits()</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>rep</key><value>rep</value></param>
<param><key>prob</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.22</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>enc</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable_dummy_encoder_def</key>
<param><key>id</key><value>enc</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_polar_encoder_def</key>
<param><key>id</key><value>enc</value></param>
<param><key>num_info_bits</key><value>4</value></param>
<param><key>block_size</key><value>8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frozen_bit_positions</key><value>[0,1,2,4]</value></param>
<param><key>frozen_bit_values</key><value>[0,0,0,0]</value></param>
<param><key>is_packed</key><value>False</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_repetition_encoder_def</key>
<param><key>id</key><value>enc</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>rep</key><value>rep</value></param>
</block>
<block>
<key>variable_dummy_encoder_def</key>
<param><key>id</key><value>enc_hdr</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_repetition_encoder_def</key>
<param><key>id</key><value>enc_hdr</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>rep</key><value>rep</value></param>
</block>
<block>
<key>variable_header_format_default</key>
<param><key>id</key><value>hdr_format</value></param>
<param><key>access_code</key><value>digital.packet_utils.default_access_code</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>threshold</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hdr_format</value></param>
<param><key>value</key><value>digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_size_test</value></param>
<param><key>comment</key><value>SINCRONISMODEQUADRO</value></param>
<param><key>value</key><value>110</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[109, 79]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rep</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts*sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>5*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>int(np.power(2,7)-1)</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Desktop/teste.wav</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Documents/engtelecom/SDR/bob.wav</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>int(np.power(2,7)-1)</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>comment</key><value>Cada bit a mais de pacote acresenta 8 na hora de inserir o cabecalho e mais 16 no buffer demux

e
we</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
<param><key>packet_len</key><value>packet_size_test</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>sample_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>sample_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>packet_size_test</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/Users/marcusbunn/Documents/engtelecom/SDR/bob.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>chan_data</value></param>
<param><key>stream_id</key><value>Chan Data</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>block_tags</key><value>True</value></param>
<param><key>epsilon</key><value>1</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>noise_voltage</key><value>0</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>packet_rx</key>
<param><key>id</key><value>packet_rx_0</value></param>
<param><key>eb</key><value>eb</value></param>
<param><key>hdr_dec</key><value>dec_hdr</value></param>
<param><key>hdr_format</key><value>hdr_format</value></param>
<param><key>hdr_const</key><value>Const_HDR</value></param>
<param><key>pld_dec</key><value>dec</value></param>
<param><key>pld_const</key><value>Const_PLD</value></param>
<param><key>psf_taps</key><value>rx_rrc_taps</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>packet_tx</key>
<param><key>id</key><value>packet_tx_0</value></param>
<param><key>hdr_enc</key><value>enc_hdr</value></param>
<param><key>hdr_format</key><value>hdr_format</value></param>
<param><key>hdr_const</key><value>Const_HDR</value></param>
<param><key>pld_enc</key><value>enc</value></param>
<param><key>pld_const</key><value>Const_PLD</value></param>
<param><key>psf_taps</key><value>tx_rrc_taps</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>RX</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>sample_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label0</key><value>Time</value></param>
<param><key>label1</key><value>Freq.</value></param>
<param><key>label2</key><value>Const.</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>label0</key><value>Time</value></param>
<param><key>label1</key><value>Freq.</value></param>
<param><key>label2</key><value>Const.</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>Chan Data</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>packet_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>packet_tx_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>chan_data</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>packet_rx_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pkt out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>packet_rx_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>pkt out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>packet_rx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>packet_rx_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>precrc</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>packet_tx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
